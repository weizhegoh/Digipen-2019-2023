# Keil uVision project Skeleton.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Skeleton +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Lib\Inc;..\Src\BSP;..\Src\BSP\MCU;..\Src\App\LED
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../Src/: main.c
  group BSP
    ../Src/BSP/: BSP.c Hal.c Hal.h IRQ.c retarget.c
    ../Src/App/LED/: LED.h
  group BSP::MCU
    ../Src/BSP/MCU/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 5.6.0
